# Keil uVision project DAC_DMA.uvproj, settings and files
target DAC_DMA (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DAC_DMA
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_wwdg.c misc.c stm32f10x_rcc.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../: main.c stm32f10x_it.c
  group STM32vldiscovery
    ../../../../Utilities/: STM32vldiscovery.c
