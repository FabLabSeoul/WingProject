# Keil uVision project Gyro-IDG-650.uvproj, settings and files
target Gyro-IDG-650 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Gyro-IDG-650
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_usart.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../: main.c stm32f10x_it.c Serial.c Retarget.c
  group STM32vldiscovery
    ../../../../Utilities/: STM32vldiscovery.c
